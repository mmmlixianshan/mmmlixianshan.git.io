# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD ,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\CJ;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LED1;..\HARDWARE\LUNZI;..\HARDWARE\PWM;..\HARDWARE\XJ;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\OBJ;..\STM32F10x_FWLib\inc;..\HARDWARE\CS;..\HARDWARE\CONTOR;..\HARDWARE\LK;..\SYSTEM;..\SYSTEM\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/LED1/: led1.c
    ../HARDWARE/LUNZI/: lunzi.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/CONTOR/: control.c
    ../HARDWARE/LK/: lk.c
    ../HARDWARE/EXTI/: exti.c
